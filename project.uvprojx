# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, STM32F103xE, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_ARM_LIBC
  c include: applications\lhc_modbus\Inc;rt-thread\components\libc\posix\io\poll;rt-thread\components\drivers\include;rt-thread\components\libc\posix\delay;rt-thread\components\libc\compilers\common\extension\fcntl\octal;.;rt-thread\libcpu\arm\cortex-m3;board;packages\CmBacktrace-v1.4.1;rt-thread\components\drivers\include;rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\posix\pthreads;rt-thread\components\libc\posix\io\stdio;libraries\HAL_Drivers;rt-thread\components\drivers\include;rt-thread\components\libc\posix\ipc;rt-thread\components\drivers\include;rt-thread\libcpu\arm\common;applications;rt-thread\components\finsh;libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;applications;applications\lhc_dwin\Inc;libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;rt-thread\components\libc\compilers\common\extension;packages\thread_pool-latest;libraries\HAL_Drivers\CMSIS\Include;rt-thread\include;libraries\HAL_Drivers\config;board\CubeMX_Config\Core\Inc;rt-thread\components\drivers\hwcrypto
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: ad9833.c test.c io_signal.c flash.c stm32_irq.c ad9833function.c main.c relay.c
    applications/lhc_modbus/Src/: small_modbus.c small_modbus_port.c
    applications/lhc_dwin/Src/: tool.c dwin.c dwin_port.c
  group cm_backtrace
    packages/CmBacktrace-v1.4.1/: cm_backtrace.c cmb_flash_log.c cmb_port.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/hwcrypto/: hwcrypto.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/pm/: lptimer.c pm.c
    rt-thread/components/drivers/serial/: serial.c
  group Drivers
    board/CubeMX_Config/Core/Src/: main.c stm32f1xx_hal_msp.c
    board/: board.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    libraries/HAL_Drivers/: drv_common.c drv_crypto.c drv_gpio.c drv_usart.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_spi.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_crc.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal.c stm32f1xx_hal_flash.c stm32f1xx_hal_cec.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_gpio.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group POSIX
    rt-thread/components/libc/posix/delay/: delay.c
    rt-thread/components/libc/posix/pthreads/: pthread.c pthread_attr.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c pthread_spin.c pthread_tls.c sched.c
  group rt_kprintf
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
  group thread_pool
    packages/thread_pool-latest/: thread_pool.c
